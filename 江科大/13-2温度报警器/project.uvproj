# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c AT24C02.c AT24C02.h Delay.c Delay.h DS18B20.c DS18B20.h I2C.c I2C.h Key.c Key.h lcd1602.c lcd1602.h Timer0.c Timer0.h public.c public.h OneWire.c OneWire.h
