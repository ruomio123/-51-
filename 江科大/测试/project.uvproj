# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c public.c lcd1602.h lcd1602.c public.h
